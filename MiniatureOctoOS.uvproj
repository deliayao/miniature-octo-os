# Keil uVision project MiniatureOctoOS.uvproj, settings and files
target MiniatureBOARD (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MiniatureOctoOS
  c flags: Optim=1
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./src/Startup/: startup_LPC17xx.s
  group System Code
    ./src/Startup/: system_LPC17xx.c
  group Source Code
    ./src/: HAL.c k_memory.c k_process.c k_rtx_init.c main_svc.c printf.c k_memory.h k_process.h k_rtx_init.h printf.h PostOffice.c PostOffice.h Timer.c Timer.h
    ./src/Polling/: uart_polling.c uart_polling.h
  group User Code
    ./src/: rtx.h usr_proc.c usr_proc.h NullProcess.c NullProcess.h
  group Utilities
    ./src/Utilities/: MemoryQueue.c PriorityQueue.c ProcessQueue.c k_rtx.h MemoryQueue.h PriorityQueue.h ProcessQueue.h Types.h Definitions.h MessageQueue.c MessageQueue.h Threading.c Threading.h
target MiniatureSIM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: MiniatureOctoOS
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
